## esp32c3/creator/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
# CONFIG_ESP_SYSTEM_MEMPROT_FEATURE is not set
# CONFIG_ESP_SYSTEM_MEMPROT_FEATURE_LOCK is not set
```
